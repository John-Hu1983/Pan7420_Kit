# Keil uVision project Project.uvprojx, settings and files
target PAN7420 (6230000::V6.23::ARMCLANG)
  device: PY32F030x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.2
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Target +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: PY32F030x8,USE_FULL_LL_DRIVER
  c include: ..\Drivers\CMSIS\Include;..\Drivers\PY32F0xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Mcu
    ../Mcu/: system_py32f0xx.c startup_py32f030xx.s
  group Drivers/PY32F0xx_HAL_Driver
    ../Drivers//PY32F0xx_HAL_Driver/Src/: py32f0xx_ll_utils.c py32f0xx_ll_gpio.c py32f0xx_ll_led.c py32f0xx_ll_dma.c py32f0xx_ll_usart.c py32f0xx_ll_rcc.c py32f0xx_ll_tim.c
    ../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_ll_i2c.c
  group Main
    ../Main/: main.c py32f0xx_it.c
  group Dev
    ../Dev/: Board.c dev_leds.c
  group Phy
    ../Phy/: phy_i2c.c phy_timer.c phy_uart.c phy_gpio.c phy_watchdog.c
  group Rfid
    ../RFid/: bsp_pn298.c bsp_rfspi_sw.c
  group Kernel
    ../Kernel/: kernel.c os_beason.c
  group App
    ../App/: app_leds.c app_oled.c
  group Oled
    ../Oled/: oled.c oled_rdwr.c
  group Gui
    ../Gui/: gui.c test.c bmp.c oledfont.c
